# Keil uVision project TactileGripper_H723VGH6.uvprojx, settings and files
target TactileGripper_H723VGH6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000100-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: TactileGripper_H723VGH6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7
  c include: ../Core/Inc;../MotorControl/Inc;../Application/Gripper/Inc;../Application/Communication/Inc;../Application/StatusIndicator/Inc;../Application/Tactile/Inc;../Platform/Inc;..\MCSDK_v6.4.1-Full\MotorControl\MCSDK\MCLib\Any\Inc;..\MCSDK_v6.4.1-Full\MotorControl\MCSDK\MCLib\H7xx\Inc;../Drivers/CMSIS/DSP/Include;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  asm include: ../Core/Inc;../MotorControl/Inc;../Application/Gripper/Inc;../Application/Communication/Inc;../Application/StatusIndicator/Inc;../Application/Tactile/Inc;../Platform/Inc;../../Reference/H745_MCSDK_OS/MCSDK_v6.4.1-Full/MotorControl/MCSDK/MCLib/Any/Inc;../../Reference/H745_MCSDK_OS/MCSDK_v6.4.1-Full/MotorControl/MCSDK/MCLib/H7xx/Inc;../Drivers/CMSIS/DSP/Include;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000100 size 0x4ff00
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c fdcan.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MotorControl
    ../MotorControl/Src/: aspep.c hf_registers.c mcp.c mcp_config.c mc_api.c mc_app_hooks.c mc_config.c mc_configuration_registers.c mc_config_common.c mc_interface.c mc_math.c mc_parameters.c mc_tasks.c mc_tasks_foc.c motorcontrol.c pwm_common.c pwm_curr_fdbk.c regular_conversion_manager.c speed_torq_ctrl.c sync_registers.c usart_aspep_driver.c kth7812_speed_pos_fdbk.c motor_control_service.c debug_uart_command.c debug_monitor.c
  group Application/Gripper
    ../Application/Gripper/Src/: gripper_controller.c gripper_service.c
  group Application/Communication
    ../Application/Communication/Src/: communication_service.c gripper_can_protocol.c
  group Application/StatusIndicator
    ../Application/StatusIndicator/Src/: status_indicator.c
  group Application/Tactile
    ../Application/Tactile/Src/: tactile_protocol.c tactile_data.c tactile_service.c
  group Platform
    ../Platform/Src/: debug_uart_transport.c ws2812_led.c can_transport.c tactile_uart_transport.c
  group Middlewares/MotorControl
    ../MCSDK_v6.4.1-Full/MotorControl/MCSDK/MCLib/H7xx/Src/: r3_2_h7xx_pwm_curr_fdbk.c
    ../MCSDK_v6.4.1-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c ntc_temperature_sensor.c pid_regulator.c pqd_motor_power_measurement.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c speed_pos_fdbk.c virtual_speed_sensor.c mcpa.c
software components: CMSIS:CORE 4.3.0
